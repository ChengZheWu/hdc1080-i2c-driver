FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://hdc1080.cfg"
